# Keil uVision project fm17520.uvprojx, settings and files
target nfc_fm17520 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Mini58ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1
  c include: ..\..\Libs\CMSIS\Include;..\..\Libs\Device\Nuvoton\Mini58Series\Include;..\..\Libs\StdDriver\inc;..\;..\source;..\des
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_Mini58Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group user
    ../: main.c
  group des
    ../des/: des.c des_enc.c ecb_enc.c set_key.c
  group source
    ../source/: system_config.c spi_driver.c fm175xx.c type_a.c ultralight.c nfc_app.c i2c_driver.c
  group Library
    ../../Libs/StdDriver/src/: retarget.c uart.c sys.c clk.c gpio.c spi.c i2c.c timer.c wdt.c wwdt.c
  group CMSIS
    ../../Libs/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../../Libs/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
software components: CMSIS:CORE 5.0.1
